# Keil uVision project BE.uvprojx, settings and files
target BE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BE +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --fp16_format=ieee
  c include: .\arm;.\cmsis;.\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./arm/: startup_MDR32F9Qx.s
  group cmsys
    ./cmsis/: core_cm3.c system_MDR32F9x.c MDR32F9Qx_iwdg.c
  group src
    ./src/: main.c init_IWDG.c init_BKP.c init.c Can.c Can.h init.h init_bkp.h init_IWDG.h parameters.h parameters_A3001001.h parameters_A3001002.h parameters_A3001003.h parameters_A3001004.h parameters_A3001005.h parameters_A3001006.h parameters_A3001007.h parameters_A3001008.h parameters_B3001001.h parameters_E3001001.h parameters_E3001002.h parameters_initial.h parameters_T3001001.h parameters_T3001002.h
software components: CMSIS:CORE 4.3.0
